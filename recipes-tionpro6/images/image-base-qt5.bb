include image-base.bb

require recipes-fsl/images/fsl-image-qt5-validation-imx.bb

