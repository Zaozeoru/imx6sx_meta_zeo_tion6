# Copyright 2019 Zao Zeo 


SRCBRANCH = "master"
SRC_URI = "git://github.com/Zaozeoru/imx6sx_uboot_2017.03.git;branch=${SRCBRANCH}"
SRCREV = "aff30494bb9545940c6768befccb42cfdb2b6471"



